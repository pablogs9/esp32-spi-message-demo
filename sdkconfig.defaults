## sdkconfig.defaults
```kconfig
CONFIG_ESP_MAIN_TASK_STACK_SIZE=6000
CONFIG_ESP_TASK_WDT=n
CONFIG_FREERTOS_SUPPORT_STATIC_ALLOCATION=y
```
